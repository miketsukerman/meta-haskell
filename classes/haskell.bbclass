HASKELL_PACKAGES = "${TMPDIR}/haskell-packages"
